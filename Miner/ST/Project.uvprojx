# Keil uVision project Project.uvprojx, settings and files
target BTCMinerBridge_F107 (6190000::V6.19::.\ARMCLANG)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTCMinerBridge_F107 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,ETH_NO_LWIP
  c include: .\Start;.\Library;.\User;.\System;.\User\lwip\include;.\User\lwip\include\ipv4;.\User\lwip
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: startup_stm32f10x_cl.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_eth.c stm32f10x_eth.h
  group System
    ./System/: Delay.c Delay.h
  group User
    ./User/: main.c eth_drv.c eth_drv.h bm1366.c bm1366.h protocol.c protocol.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
