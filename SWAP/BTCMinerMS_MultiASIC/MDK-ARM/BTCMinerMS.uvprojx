# Keil uVision project BTCMinerMS.uvprojx, settings and files
target BTCMinerMS (5060960::V5.06 update 7 (build 960)::..\..\ARM\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: BTCMinerMS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Inc/Library;../Library/LwIP/src/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: startup_stm32f10x_cl.s bm1366.c debug_serial.c Delay.c eth_drv.c protocol.c tps546d24a.c tmp1075.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/Src/Library/: lwip_eth.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group LwIP
    ../Library/LwIP/src/core/: def.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c stats.c sys.c timeouts.c tcp.c tcp_in.c tcp_out.c udp.c ip.c
    ../Library/LwIP/src/core/ipv4/: ip4.c ip4_addr.c etharp.c icmp.c dhcp.c acd.c
    ../Library/LwIP/src/netif/: ethernet.c
    ../Core/Src/: sys_arch.c eth_netif.c
